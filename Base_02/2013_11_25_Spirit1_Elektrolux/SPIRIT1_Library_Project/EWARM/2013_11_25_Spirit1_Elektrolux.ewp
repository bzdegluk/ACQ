# IAR project 2013_11_25_Spirit1_Elektrolux.ewp, settings and files
configuration DZ-SB-DISC01 (ARM, debug)
  General.OGChipSelectEditMenu: STM32L151xB ST STM32L151xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; VECT_TAB_FLASH; STM32L1XX_MD; IAR_ARM_CM3; USE_FULL_ASSERT; SPIRIT_USE_FULL_ASSERT; USE_SYSTICK_DELAY; SDK
  ICCARM.CCIncludePath2: .; ..\Application; ..\Application\examples; ..\Application\runtime; ..\..\STM32L\SDK_Eval_STM32L\Source\inc; ..\SPIRIT1_Library\Source\inc; ..\SDK_Eval_Util\Source\inc; ..\..\STM32L\STM32L1xx_StdPeriph_Lib\Source\CMSIS\CM3\DeviceSupport\ST\STM32L1xx; ..\..\STM32L\STM32L1xx_StdPeriph_Lib\Source\STM32L1xx_StdPeriph_Driver\inc; ..\..\STM32L\SDK_Virtual_Com\Source\inc; ..\..\STM32L\STM32_USB-FS-Device_Lib\Source\inc; ..\ACQ
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: 2013_11_25_Spirit1_SB_Disc01_Elektrolux.hex
  ILINK.IlinkOutputFile: 2013_11_25_Spirit1_SB_Disc01_Elektrolux.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration DZ-SBD-MB01 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: .; ..\Application; ..\Application\examples; ..\Application\runtime; ..\..\STM32L\SDK_Eval_STM32L\Source\inc; ..\SPIRIT1_Library\Source\inc; ..\SDK_Eval_Util\Source\inc; ..\..\STM32L\STM32L1xx_StdPeriph_Lib\Source\CMSIS\CM3\DeviceSupport\ST\STM32L1xx; ..\..\STM32L\STM32L1xx_StdPeriph_Lib\Source\STM32L1xx_StdPeriph_Driver\inc; ..\..\STM32L\SDK_Virtual_Com\Source\inc; ..\..\STM32L\STM32_USB-FS-Device_Lib\Source\inc
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: 2013_11_25_Spirit1_SBD_MB01_Elektrolux.hex
  ILINK.IlinkOutputFile: 2013_11_25_Spirit1_SBD_MB01_Elektrolux.out
  ILINK.IlinkIcfFile: stm32l1xx_flash.icf
  group ACQ/inc
    ../ACQ/: ACQ.h
  group ACQ/src
    ../ACQ/: ACQ.c
  group Runtime
    ../Application/runtime/iar/: startup_stm32l1xx_hd.s
    ../Application/runtime/: system_stm32l1xx.c
  group SDK_Eval/inc
    ../../STM32L/SDK_Eval_STM32L/Source/inc/: SDK_EVAL_Button.h SDK_EVAL_Com.h SDK_EVAL_Config.h SDK_EVAL_Gpio.h SDK_EVAL_Led.h SDK_EVAL_PM.h SDK_EVAL_Timers.h
  group SDK_Eval/src
    ../../STM32L/SDK_Eval_STM32L/Source/src/: SDK_EVAL_Button.c SDK_EVAL_Com.c SDK_EVAL_Config.c SDK_EVAL_Gpio.c SDK_EVAL_Led.c SDK_EVAL_PM.c SDK_EVAL_Spi_Driver.c SDK_EVAL_Timers.c
  group SDK_Eval_VC/inc
    ../../STM32L/SDK_Virtual_Com/Source/inc/: SDK_EVAL_VC_Desc.h SDK_EVAL_VC_General.h SDK_EVAL_VC_Istr.h SDK_EVAL_VC_Prop.h SDK_EVAL_VC_Pwr.h usb_conf.h
  group SDK_Eval_VC/src
    ../../STM32L/SDK_Virtual_Com/Source/src/: SDK_EVAL_VC_Desc.c SDK_EVAL_VC_Endp.c SDK_EVAL_VC_General.c SDK_EVAL_VC_Istr.c SDK_EVAL_VC_Prop.c SDK_EVAL_VC_Pwr.c
  group Serwer
    ../Serwer/: Serwer.h
  group SPIRIT1_Libraries/inc
    ../SPIRIT1_Library/Source/inc/: MCU_Interface.h SPIRIT_Aes.h SPIRIT_Calibration.h SPIRIT_Commands.h SPIRIT_Config.h SPIRIT_Csma.h SPIRIT_DirectRF.h SPIRIT_General.h SPIRIT_Gpio.h SPIRIT_Irq.h SPIRIT_LinearFifo.h SPIRIT_Management.h SPIRIT_PktBasic.h SPIRIT_PktCommon.h SPIRIT_PktMbus.h SPIRIT_PktStack.h SPIRIT_Qi.h SPIRIT_Radio.h SPIRIT_Regs.h SPIRIT_Timer.h SPIRIT_Types.h
  group SPIRIT1_Libraries/src
    ../SPIRIT1_Library/Source/src/: SPIRIT_Aes.c SPIRIT_Calibration.c SPIRIT_Commands.c SPIRIT_Csma.c SPIRIT_DirectRF.c SPIRIT_General.c SPIRIT_Gpio.c SPIRIT_Irq.c SPIRIT_LinearFifo.c SPIRIT_Management.c SPIRIT_PktBasic.c SPIRIT_PktCommon.c SPIRIT_PktMbus.c SPIRIT_PktStack.c SPIRIT_Qi.c SPIRIT_Radio.c SPIRIT_Timer.c SPIRIT_Types.c
  group STM32_USB-FS-Device_Driver/inc
    ../../STM32L/STM32_USB-FS-Device_Lib/Source/inc/: usb_core.h usb_def.h usb_init.h usb_int.h usb_lib.h usb_mem.h usb_regs.h usb_sil.h usb_type.h
  group STM32_USB-FS-Device_Driver/src
    ../../STM32L/STM32_USB-FS-Device_Lib/Source/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group STM32L1xx_StdPeriph_Lib/inc
    ../../STM32L/STM32L1xx_StdPeriph_Lib/Source/STM32L1xx_StdPeriph_Driver/inc/: misc.h stm32l1xx_adc.h stm32l1xx_comp.h stm32l1xx_crc.h stm32l1xx_dac.h stm32l1xx_dbgmcu.h stm32l1xx_dma.h stm32l1xx_exti.h stm32l1xx_flash.h stm32l1xx_gpio.h stm32l1xx_i2c.h stm32l1xx_iwdg.h stm32l1xx_lcd.h stm32l1xx_pwr.h stm32l1xx_rcc.h stm32l1xx_rtc.h stm32l1xx_spi.h stm32l1xx_syscfg.h stm32l1xx_tim.h stm32l1xx_usart.h stm32l1xx_wwdg.h
  group STM32L1xx_StdPeriph_Lib/src
    ../../STM32L/STM32L1xx_StdPeriph_Lib/Source/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_adc.c stm32l1xx_comp.c stm32l1xx_crc.c stm32l1xx_dac.c stm32l1xx_dbgmcu.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_flash_ramfunc.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_iwdg.c stm32l1xx_lcd.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c stm32l1xx_wwdg.c
  group Test
    ../Application/examples/BasicGeneric/: Base_Station.c DZ-SB-DISC01.c DZ-SBD-MB01.c End_Point.c UART.c UART.h
    ../Application/: SDK_Configuration_Common.h stm32l1xx_conf.h stm32l1xx_it.c stm32l1xx_it.h
    ../SDK_Eval_Util/Source/src/: SPIRIT_SDK_Application.c SPIRIT_SDK_EEPROM.c
  group Test/ReadMe
    ../../StackLlp/StackLlp/: SDK_StackLlp_readme.txt
