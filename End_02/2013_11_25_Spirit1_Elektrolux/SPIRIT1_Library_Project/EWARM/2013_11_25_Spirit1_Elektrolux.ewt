<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>DZ-SB-DISC01</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>DZ-SBD-MB01</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>ACQ</name>
    <group>
      <name>inc</name>
      <file>
        <name>$PROJ_DIR$\..\ACQ\ACQ.h</name>
      </file>
    </group>
    <group>
      <name>src</name>
      <file>
        <name>$PROJ_DIR$\..\ACQ\ACQ.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>Runtime</name>
    <file>
      <name>$PROJ_DIR$\..\Application\runtime\iar\startup_stm32l1xx_hd.s</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Application\runtime\system_stm32l1xx.c</name>
    </file>
  </group>
  <group>
    <name>SDK_Eval</name>
    <group>
      <name>inc</name>
      <file>
        <name>$PROJ_DIR$\..\..\STM32L\SDK_Eval_STM32L\Source\inc\SDK_EVAL_Button.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\STM32L\SDK_Eval_STM32L\Source\inc\SDK_EVAL_Com.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\STM32L\SDK_Eval_STM32L\Source\inc\SDK_EVAL_Config.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\STM32L\SDK_Eval_STM32L\Source\inc\SDK_EVAL_Gpio.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\STM32L\SDK_Eval_STM32L\Source\inc\SDK_EVAL_Led.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\STM32L\SDK_Eval_STM32L\Source\inc\SDK_EVAL_PM.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\STM32L\SDK_Eval_STM32L\Source\inc\SDK_EVAL_Timers.h</name>
      </file>
    </group>
    <group>
      <name>src</name>
      <file>
        <name>$PROJ_DIR$\..\..\STM32L\SDK_Eval_STM32L\Source\src\SDK_EVAL_Button.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\STM32L\SDK_Eval_STM32L\Source\src\SDK_EVAL_Com.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\STM32L\SDK_Eval_STM32L\Source\src\SDK_EVAL_Config.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\STM32L\SDK_Eval_STM32L\Source\src\SDK_EVAL_Gpio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\STM32L\SDK_Eval_STM32L\Source\src\SDK_EVAL_Led.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\STM32L\SDK_Eval_STM32L\Source\src\SDK_EVAL_PM.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\STM32L\SDK_Eval_STM32L\Source\src\SDK_EVAL_Spi_Driver.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\STM32L\SDK_Eval_STM32L\Source\src\SDK_EVAL_Timers.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>SDK_Eval_VC</name>
    <group>
      <name>inc</name>
      <file>
        <name>$PROJ_DIR$\..\..\STM32L\SDK_Virtual_Com\Source\inc\SDK_EVAL_VC_Desc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\STM32L\SDK_Virtual_Com\Source\inc\SDK_EVAL_VC_General.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\STM32L\SDK_Virtual_Com\Source\inc\SDK_EVAL_VC_Istr.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\STM32L\SDK_Virtual_Com\Source\inc\SDK_EVAL_VC_Prop.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\STM32L\SDK_Virtual_Com\Source\inc\SDK_EVAL_VC_Pwr.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\STM32L\SDK_Virtual_Com\Source\inc\usb_conf.h</name>
      </file>
    </group>
    <group>
      <name>src</name>
      <file>
        <name>$PROJ_DIR$\..\..\STM32L\SDK_Virtual_Com\Source\src\SDK_EVAL_VC_Desc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\STM32L\SDK_Virtual_Com\Source\src\SDK_EVAL_VC_Endp.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\STM32L\SDK_Virtual_Com\Source\src\SDK_EVAL_VC_General.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\STM32L\SDK_Virtual_Com\Source\src\SDK_EVAL_VC_Istr.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\STM32L\SDK_Virtual_Com\Source\src\SDK_EVAL_VC_Prop.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\STM32L\SDK_Virtual_Com\Source\src\SDK_EVAL_VC_Pwr.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>SPIRIT1_Libraries</name>
    <group>
      <name>inc</name>
      <file>
        <name>$PROJ_DIR$\..\SPIRIT1_Library\Source\inc\MCU_Interface.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\SPIRIT1_Library\Source\inc\SPIRIT_Aes.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\SPIRIT1_Library\Source\inc\SPIRIT_Calibration.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\SPIRIT1_Library\Source\inc\SPIRIT_Commands.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\SPIRIT1_Library\Source\inc\SPIRIT_Config.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\SPIRIT1_Library\Source\inc\SPIRIT_Csma.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\SPIRIT1_Library\Source\inc\SPIRIT_DirectRF.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\SPIRIT1_Library\Source\inc\SPIRIT_General.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\SPIRIT1_Library\Source\inc\SPIRIT_Gpio.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\SPIRIT1_Library\Source\inc\SPIRIT_Irq.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\SPIRIT1_Library\Source\inc\SPIRIT_LinearFifo.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\SPIRIT1_Library\Source\inc\SPIRIT_Management.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\SPIRIT1_Library\Source\inc\SPIRIT_PktBasic.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\SPIRIT1_Library\Source\inc\SPIRIT_PktCommon.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\SPIRIT1_Library\Source\inc\SPIRIT_PktMbus.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\SPIRIT1_Library\Source\inc\SPIRIT_PktStack.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\SPIRIT1_Library\Source\inc\SPIRIT_Qi.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\SPIRIT1_Library\Source\inc\SPIRIT_Radio.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\SPIRIT1_Library\Source\inc\SPIRIT_Regs.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\SPIRIT1_Library\Source\inc\SPIRIT_Timer.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\SPIRIT1_Library\Source\inc\SPIRIT_Types.h</name>
      </file>
    </group>
    <group>
      <name>src</name>
      <file>
        <name>$PROJ_DIR$\..\SPIRIT1_Library\Source\src\SPIRIT_Aes.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\SPIRIT1_Library\Source\src\SPIRIT_Calibration.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\SPIRIT1_Library\Source\src\SPIRIT_Commands.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\SPIRIT1_Library\Source\src\SPIRIT_Csma.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\SPIRIT1_Library\Source\src\SPIRIT_DirectRF.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\SPIRIT1_Library\Source\src\SPIRIT_General.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\SPIRIT1_Library\Source\src\SPIRIT_Gpio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\SPIRIT1_Library\Source\src\SPIRIT_Irq.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\SPIRIT1_Library\Source\src\SPIRIT_LinearFifo.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\SPIRIT1_Library\Source\src\SPIRIT_Management.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\SPIRIT1_Library\Source\src\SPIRIT_PktBasic.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\SPIRIT1_Library\Source\src\SPIRIT_PktCommon.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\SPIRIT1_Library\Source\src\SPIRIT_PktMbus.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\SPIRIT1_Library\Source\src\SPIRIT_PktStack.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\SPIRIT1_Library\Source\src\SPIRIT_Qi.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\SPIRIT1_Library\Source\src\SPIRIT_Radio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\SPIRIT1_Library\Source\src\SPIRIT_Timer.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\SPIRIT1_Library\Source\src\SPIRIT_Types.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>STM32_USB-FS-Device_Driver</name>
    <group>
      <name>inc</name>
      <file>
        <name>$PROJ_DIR$\..\..\STM32L\STM32_USB-FS-Device_Lib\Source\inc\usb_core.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\STM32L\STM32_USB-FS-Device_Lib\Source\inc\usb_def.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\STM32L\STM32_USB-FS-Device_Lib\Source\inc\usb_init.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\STM32L\STM32_USB-FS-Device_Lib\Source\inc\usb_int.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\STM32L\STM32_USB-FS-Device_Lib\Source\inc\usb_lib.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\STM32L\STM32_USB-FS-Device_Lib\Source\inc\usb_mem.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\STM32L\STM32_USB-FS-Device_Lib\Source\inc\usb_regs.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\STM32L\STM32_USB-FS-Device_Lib\Source\inc\usb_sil.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\STM32L\STM32_USB-FS-Device_Lib\Source\inc\usb_type.h</name>
      </file>
    </group>
    <group>
      <name>src</name>
      <file>
        <name>$PROJ_DIR$\..\..\STM32L\STM32_USB-FS-Device_Lib\Source\src\usb_core.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\STM32L\STM32_USB-FS-Device_Lib\Source\src\usb_init.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\STM32L\STM32_USB-FS-Device_Lib\Source\src\usb_int.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\STM32L\STM32_USB-FS-Device_Lib\Source\src\usb_mem.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\STM32L\STM32_USB-FS-Device_Lib\Source\src\usb_regs.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\STM32L\STM32_USB-FS-Device_Lib\Source\src\usb_sil.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>STM32L1xx_StdPeriph_Lib</name>
    <group>
      <name>inc</name>
      <file>
        <name>$PROJ_DIR$\..\..\STM32L\STM32L1xx_StdPeriph_Lib\Source\STM32L1xx_StdPeriph_Driver\inc\misc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\STM32L\STM32L1xx_StdPeriph_Lib\Source\STM32L1xx_StdPeriph_Driver\inc\stm32l1xx_adc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\STM32L\STM32L1xx_StdPeriph_Lib\Source\STM32L1xx_StdPeriph_Driver\inc\stm32l1xx_comp.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\STM32L\STM32L1xx_StdPeriph_Lib\Source\STM32L1xx_StdPeriph_Driver\inc\stm32l1xx_crc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\STM32L\STM32L1xx_StdPeriph_Lib\Source\STM32L1xx_StdPeriph_Driver\inc\stm32l1xx_dac.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\STM32L\STM32L1xx_StdPeriph_Lib\Source\STM32L1xx_StdPeriph_Driver\inc\stm32l1xx_dbgmcu.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\STM32L\STM32L1xx_StdPeriph_Lib\Source\STM32L1xx_StdPeriph_Driver\inc\stm32l1xx_dma.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\STM32L\STM32L1xx_StdPeriph_Lib\Source\STM32L1xx_StdPeriph_Driver\inc\stm32l1xx_exti.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\STM32L\STM32L1xx_StdPeriph_Lib\Source\STM32L1xx_StdPeriph_Driver\inc\stm32l1xx_flash.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\STM32L\STM32L1xx_StdPeriph_Lib\Source\STM32L1xx_StdPeriph_Driver\inc\stm32l1xx_gpio.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\STM32L\STM32L1xx_StdPeriph_Lib\Source\STM32L1xx_StdPeriph_Driver\inc\stm32l1xx_i2c.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\STM32L\STM32L1xx_StdPeriph_Lib\Source\STM32L1xx_StdPeriph_Driver\inc\stm32l1xx_iwdg.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\STM32L\STM32L1xx_StdPeriph_Lib\Source\STM32L1xx_StdPeriph_Driver\inc\stm32l1xx_lcd.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\STM32L\STM32L1xx_StdPeriph_Lib\Source\STM32L1xx_StdPeriph_Driver\inc\stm32l1xx_pwr.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\STM32L\STM32L1xx_StdPeriph_Lib\Source\STM32L1xx_StdPeriph_Driver\inc\stm32l1xx_rcc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\STM32L\STM32L1xx_StdPeriph_Lib\Source\STM32L1xx_StdPeriph_Driver\inc\stm32l1xx_rtc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\STM32L\STM32L1xx_StdPeriph_Lib\Source\STM32L1xx_StdPeriph_Driver\inc\stm32l1xx_spi.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\STM32L\STM32L1xx_StdPeriph_Lib\Source\STM32L1xx_StdPeriph_Driver\inc\stm32l1xx_syscfg.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\STM32L\STM32L1xx_StdPeriph_Lib\Source\STM32L1xx_StdPeriph_Driver\inc\stm32l1xx_tim.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\STM32L\STM32L1xx_StdPeriph_Lib\Source\STM32L1xx_StdPeriph_Driver\inc\stm32l1xx_usart.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\STM32L\STM32L1xx_StdPeriph_Lib\Source\STM32L1xx_StdPeriph_Driver\inc\stm32l1xx_wwdg.h</name>
      </file>
    </group>
    <group>
      <name>src</name>
      <file>
        <name>$PROJ_DIR$\..\..\STM32L\STM32L1xx_StdPeriph_Lib\Source\STM32L1xx_StdPeriph_Driver\src\misc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\STM32L\STM32L1xx_StdPeriph_Lib\Source\STM32L1xx_StdPeriph_Driver\src\stm32l1xx_adc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\STM32L\STM32L1xx_StdPeriph_Lib\Source\STM32L1xx_StdPeriph_Driver\src\stm32l1xx_comp.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\STM32L\STM32L1xx_StdPeriph_Lib\Source\STM32L1xx_StdPeriph_Driver\src\stm32l1xx_crc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\STM32L\STM32L1xx_StdPeriph_Lib\Source\STM32L1xx_StdPeriph_Driver\src\stm32l1xx_dac.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\STM32L\STM32L1xx_StdPeriph_Lib\Source\STM32L1xx_StdPeriph_Driver\src\stm32l1xx_dbgmcu.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\STM32L\STM32L1xx_StdPeriph_Lib\Source\STM32L1xx_StdPeriph_Driver\src\stm32l1xx_dma.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\STM32L\STM32L1xx_StdPeriph_Lib\Source\STM32L1xx_StdPeriph_Driver\src\stm32l1xx_exti.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\STM32L\STM32L1xx_StdPeriph_Lib\Source\STM32L1xx_StdPeriph_Driver\src\stm32l1xx_flash.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\STM32L\STM32L1xx_StdPeriph_Lib\Source\STM32L1xx_StdPeriph_Driver\src\stm32l1xx_flash_ramfunc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\STM32L\STM32L1xx_StdPeriph_Lib\Source\STM32L1xx_StdPeriph_Driver\src\stm32l1xx_gpio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\STM32L\STM32L1xx_StdPeriph_Lib\Source\STM32L1xx_StdPeriph_Driver\src\stm32l1xx_i2c.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\STM32L\STM32L1xx_StdPeriph_Lib\Source\STM32L1xx_StdPeriph_Driver\src\stm32l1xx_iwdg.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\STM32L\STM32L1xx_StdPeriph_Lib\Source\STM32L1xx_StdPeriph_Driver\src\stm32l1xx_lcd.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\STM32L\STM32L1xx_StdPeriph_Lib\Source\STM32L1xx_StdPeriph_Driver\src\stm32l1xx_pwr.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\STM32L\STM32L1xx_StdPeriph_Lib\Source\STM32L1xx_StdPeriph_Driver\src\stm32l1xx_rcc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\STM32L\STM32L1xx_StdPeriph_Lib\Source\STM32L1xx_StdPeriph_Driver\src\stm32l1xx_rtc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\STM32L\STM32L1xx_StdPeriph_Lib\Source\STM32L1xx_StdPeriph_Driver\src\stm32l1xx_spi.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\STM32L\STM32L1xx_StdPeriph_Lib\Source\STM32L1xx_StdPeriph_Driver\src\stm32l1xx_syscfg.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\STM32L\STM32L1xx_StdPeriph_Lib\Source\STM32L1xx_StdPeriph_Driver\src\stm32l1xx_tim.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\STM32L\STM32L1xx_StdPeriph_Lib\Source\STM32L1xx_StdPeriph_Driver\src\stm32l1xx_usart.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\STM32L\STM32L1xx_StdPeriph_Lib\Source\STM32L1xx_StdPeriph_Driver\src\stm32l1xx_wwdg.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>Test</name>
    <group>
      <name>ReadMe</name>
      <file>
        <name>$PROJ_DIR$\..\..\StackLlp\StackLlp\SDK_StackLlp_readme.txt</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\Application\examples\BasicGeneric\Base_Station.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Application\examples\BasicGeneric\DZ-SB-DISC01.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Application\examples\BasicGeneric\DZ-SBD-MB01.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Application\examples\BasicGeneric\End_Point.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Application\SDK_Configuration_Common.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\SDK_Eval_Util\Source\src\SPIRIT_SDK_Application.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\SDK_Eval_Util\Source\src\SPIRIT_SDK_EEPROM.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Application\stm32l1xx_conf.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Application\stm32l1xx_it.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Application\stm32l1xx_it.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Application\examples\BasicGeneric\UART.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Application\examples\BasicGeneric\UART.h</name>
    </file>
  </group>
</project>


