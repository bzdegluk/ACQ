# IAR project 2013_11_25_STM32L_Discovery_for_Spirit1_Elektrolux.ewp, settings and files
configuration STM32L-Discovery (ARM, debug)
  General.OGChipSelectEditMenu: STM32L152x8 ST STM32L152x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: STM32L15XXB_128K; USE_FULL_ASSERT; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\libraries\STM32L1xx_StdPeriph_Driver\inc; ..\..\..\libraries\STM32_TouchSensing_Driver\inc; ..\..\..\libraries\CMSIS\CM3\DeviceSupport\ST\STM32L1xx; ..\..\..\Utilities\STM32L-DISCOVERY
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: 2013_11_25_STM32L_Discovery_for_Spirit1_Elektrolux.hex
  ILINK.IlinkOutputFile: 2013_11_25_STM32L_Discovery_for_Spirit1_Elektrolux.out
  ILINK.IlinkIcfFile: stm32l1xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
  group EWARM
    ../../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32L1xx/startup/iar/: startup_stm32l1xx_md.s
  group STM32L-Discovery
    ../../../Utilities/STM32L-DISCOVERY/: stm32l_discovery_lcd.c
  group STM32L1xx_StdPeriph_Driver
    ../../../Libraries/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_adc.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_gpio.c stm32l1xx_lcd.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_syscfg.c stm32l1xx_usart.c
  group TouchSensingDriver
    ../../../Libraries/STM32_TouchSensing_Driver/src/: stm32_tsl_api.c stm32_tsl_multichannelkey.c stm32_tsl_services.c stm32_tsl_singlechannelkey.c stm32_tsl_timebase.c stm32l15x_tsl_ct_acquisition.c
  group User
    ../src/: discovery_functions.c main.c stm32l1xx_it.c system_stm32l1xx.c
