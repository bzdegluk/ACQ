<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\2013_11_25_STM32L_Discovery_for_Spirit1_Elektrolux.ewp</path>
  </project>
  <batchBuild/>
</workspace>


